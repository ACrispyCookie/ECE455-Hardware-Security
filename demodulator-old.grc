options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Demodulator of RAM
  states: {}

blocks:
- name: sample_rate_i
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: selected_frequency
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '80000'
    step: '10000'
    stop: '3650000000'
    value: '1333833000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '8'
    quad_rate: '384000'
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '500'
    low_cutoff_freq: '0'
    samp_rate: sample_rate_i
    type: fir_filter_ccc
    width: '3000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_endian_swap_0
  id: blocks_endian_swap
  parameters:
    type: s16
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/tsiantosd/Desktop/TsiantosD/ECE455-Hardware-Security/message.bin
    type: float
  states: {state: disabled}
- name: blocks_file_sink_1_0_0
  id: blocks_file_sink
  parameters:
    file: /home/tsiantosd/Desktop/TsiantosD/ECE455-Hardware-Security/message.bin
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_1_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/tsiantosd/Desktop/TsiantosD/ECE455-Hardware-Security/message-packed.bin
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_2
  id: blocks_file_sink
  parameters:
    file: ~/Desktop/output.txt
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_2_0
  id: blocks_file_sink
  parameters:
    file: /home/tsiantosd/Desktop/output.txt
    type: byte
  states: {}
- name: blocks_float_to_char_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_float_to_char_0_0_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '1'
    type: float
    vlen: '2000000'
  states: {state: disabled}
- name: blocks_keep_one_in_n_0_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '65105'
    type: byte
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '65105'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: sample_rate_i
    max_iter: sample_rate_i
    scale: '1'
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_2
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1'
    type: float
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.1'
    init: '0'
    low: '0.05'
  states: {state: disabled}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '0.1'
    init: '0'
    low: '0.05'
  states: {state: disabled}
- name: blocks_threshold_ff_1
  id: blocks_threshold_ff
  parameters:
    high: '0.0025'
    init: '0'
    low: '0.0015'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: sample_rate_i
    type: float
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: short
  states: {state: disabled}
- name: blocks_vector_sink_x_0
  id: blocks_vector_sink_x
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /home/tsiantosd/Desktop/test.wav
    format: FORMAT_WAV
    samp_rate: '44100'
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: digital_binary_slicer_fb_1
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: selected_frequency
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: sample_rate_i
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '44100'
    decim: '7'
    gain: '1'
    samp_rate: sample_rate_i
    type: fir_filter_ccf
    width: '44100'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '1.5'
    decim: '1'
    gain: '1'
    samp_rate: sample_rate_i
    type: fir_filter_fff
    width: '0.2'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '1.5'
    decim: '1'
    gain: '1'
    samp_rate: sample_rate_i
    type: fir_filter_fff
    width: '0.2'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_2
  id: low_pass_filter
  parameters:
    cutoff_freq: '300'
    decim: '1'
    gain: '1'
    samp_rate: sample_rate_i
    type: fir_filter_fff
    width: '2'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    size: '1024'
    type: float
    xmax: '1'
    xmin: '-1'
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Translated Bit"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Filtered Float Value"'
    type: float
    update_time: '0.5'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Filtered Float Value Amplitude"'
    size: '1024'
    srate: sample_rate_i
    type: float
    update_time: '0.5'
    ymax: '0.01'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Filtered Float Value Amplitude"'
    size: '1024'
    srate: sample_rate_i
    type: float
    update_time: '0.5'
    ymax: '0.01'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate_i
    fc: '0'
    fftsize: '1024'
    name: '"Waterfall"'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: sample_rate_i
    fc: '0'
    fftsize: '1024'
    name: '"Waterfall"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '65105'
    interp: '1'
    type: fff
  states: {state: disabled}

connections:
- [analog_wfm_rcv_0, '0', blocks_wavfile_sink_0, '0']
- [band_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [band_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_char_to_float_1, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_complex_to_float_0, '0', low_pass_filter_1_0, '0']
- [blocks_complex_to_mag_0, '0', low_pass_filter_2, '0']
- [blocks_complex_to_mag_squared_0, '0', low_pass_filter_1, '0']
- [blocks_float_to_char_0_0, '0', blocks_file_sink_1_0_0, '0']
- [blocks_float_to_char_0_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_float_to_char_0_0_0, '0', blocks_file_sink_1_0_0, '0']
- [blocks_keep_one_in_n_0_0_0, '0', blocks_float_to_char_0_0_0, '0']
- [blocks_keep_one_in_n_0_0_0, '0', blocks_pack_k_bits_bb_2, '0']
- [blocks_keep_one_in_n_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_moving_average_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_moving_average_xx_0_0, '0', digital_binary_slicer_fb_1, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_char_to_float_1, '0']
- [blocks_pack_k_bits_bb_1, '0', blocks_file_sink_2, '0']
- [blocks_pack_k_bits_bb_2, '0', blocks_file_sink_2_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_vector_sink_x_0, '0']
- [blocks_threshold_ff_0, '0', blocks_file_sink_0, '0']
- [blocks_threshold_ff_1, '0', blocks_file_sink_1, '0']
- [blocks_threshold_ff_1, '0', blocks_keep_one_in_n_0, '0']
- [blocks_threshold_ff_1, '0', blocks_moving_average_xx_0, '0']
- [blocks_threshold_ff_1, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_threshold_ff_1, '0', blocks_stream_to_vector_0, '0']
- [blocks_threshold_ff_1, '0', blocks_throttle_0, '0']
- [blocks_threshold_ff_1, '0', digital_binary_slicer_fb_0, '0']
- [blocks_threshold_ff_1, '0', qtgui_number_sink_0, '0']
- [blocks_throttle_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_1_0_0_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_pack_k_bits_bb_1, '0']
- [digital_binary_slicer_fb_1, '0', blocks_keep_one_in_n_0_0_0, '0']
- [iio_pluto_source_0, '0', band_pass_filter_0, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_float_0, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_1, '0', blocks_threshold_ff_0, '0']
- [low_pass_filter_1_0, '0', blocks_threshold_ff_0_0, '0']
- [low_pass_filter_2, '0', blocks_threshold_ff_1, '0']
- [low_pass_filter_2, '0', qtgui_number_sink_0_0, '0']
- [low_pass_filter_2, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', blocks_float_to_char_0_0, '0']

metadata:
  file_format: 1
