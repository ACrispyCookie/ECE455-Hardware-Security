options:
  parameters:
    author: tsiantosd
    generate_options: qt_gui
    id: ook_demodulator
    output_language: python
    title: OOK Demodulator
  states: {}

blocks:
- name: bitss
  id: variable
  parameters:
    value: '8'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: selected_frequency
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '80000'
    step: '10000'
    stop: '3999939000'
    value: '1333313000'
  states: {}
- name: selected_frequency
  id: variable
  parameters:
    value: '2666626000'
  states: {state: disabled}
- name: sps
  id: variable
  parameters:
    value: samp_rate
  states: {state: disabled}
- name: sps
  id: variable
  parameters:
    value: samp_rate//bitss
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-130'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/output.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/tsiantosd/Desktop/hello_world-capture.raw
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '1'
    n: sps
    offset: sps//2
    type: float
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: sps//2
    type: float
  states: {state: disabled}
- name: blocks_keep_one_in_n_0_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '2'
    type: float
  states: {state: disabled}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    n: sps
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: samp_rate
    max_iter: '4000'
    scale: '1'
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '100'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: sps
    type: complex
  states: {state: disabled}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: sps//2
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1'
    type: float
    vlen: samp_rate
  states: {state: disabled}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.12'
    init: '0'
    low: '0.08'
  states: {}
- name: blocks_threshold_ff_1
  id: blocks_threshold_ff
  parameters:
    high: '600000'
    init: '0'
    low: '400000'
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (0, 1, 0, 1, 0, 0, 1, 1)
  states: {state: disabled}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '10101001'
    tagname: frame_start
    threshold: '0'
    type: byte
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: ff
  states: {state: disabled}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: sps
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: ff
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: samp_rate
    taps: '1'
    type: fff
  states: {state: disabled}
- name: iio_pluto_source_1
  id: iio_pluto_source
  parameters:
    bandwidth: '200000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: selected_frequency
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Keep 1 in N
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: AVG
    type: float
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: RX raw Re
    label2: RX raw Im
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    label1: RX raw magnitude
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: TX Re
    label2: TX Im
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    label1: RX Threshold
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: RX Moving Average
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '500'
    ymin: '-500'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: RX Keep 1 in N
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '500'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: RX AVG
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '500'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_1
  id: qtgui_time_sink_x
  parameters:
    label1: RX Sync
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: RX raw
    type: complex
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {state: disabled}

connections:
- [analog_pwr_squelch_xx_0, '0', blocks_complex_to_mag_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_mag_0, '0', digital_symbol_sync_xx_0_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_char_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [blocks_integrate_xx_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_float_to_char_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_threshold_ff_1, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_number_sink_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_1_0_0_0, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_keep_one_in_n_0_0_0, '0']
- [blocks_keep_one_in_n_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_keep_one_in_n_0_0_0, '0', blocks_float_to_char_0, '0']
- [blocks_keep_one_in_n_1, '0', blocks_float_to_char_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_moving_average_xx_0_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_moving_average_xx_0_0, '0', qtgui_time_sink_x_1_0_0_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_xx_0, '0', virtual_sink_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_repeat_0, '0', blocks_multiply_xx_0, '0']
- [blocks_skiphead_0, '0', blocks_keep_one_in_n_1, '0']
- [blocks_threshold_ff_0, '0', blocks_integrate_xx_0, '0']
- [blocks_threshold_ff_0, '0', blocks_keep_m_in_n_0, '0']
- [blocks_threshold_ff_0, '0', blocks_keep_one_in_n_0_0, '0']
- [blocks_threshold_ff_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_threshold_ff_0, '0', blocks_skiphead_0, '0']
- [blocks_threshold_ff_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_threshold_ff_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_threshold_ff_0, '0', fir_filter_xxx_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_threshold_ff_1, '0', blocks_float_to_char_0, '0']
- [blocks_throttle_0, '0', low_pass_filter_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', blocks_repeat_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_keep_m_in_n_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_keep_one_in_n_0_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_time_sink_x_1_0_1, '0']
- [digital_symbol_sync_xx_0_0, '0', blocks_threshold_ff_0, '0']
- [fir_filter_xxx_0, '0', blocks_threshold_ff_1, '0']
- [fir_filter_xxx_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [iio_pluto_source_1, '0', low_pass_filter_0, '0']
- [iio_pluto_source_1, '0', qtgui_sink_x_0, '0']
- [iio_pluto_source_1, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_pwr_squelch_xx_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0_0, '0']
- [virtual_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
