options:
  parameters:
    author: PANAGIVTHS
    generate_options: qt_gui
    id: ook_demodulator_AGC
    output_language: python
    title: Agc version of demodulator
  states: {}

blocks:
- name: bit_samples
  id: variable
  parameters:
    value: '700'
  states: {}
- name: bitss
  id: variable
  parameters:
    value: '8'
  states: {}
- name: cutoff_linear_vol
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '20'
  states: {}
- name: n_keep
  id: variable
  parameters:
    value: int(bit_samples * 0.3)
  states: {}
- name: n_skip
  id: variable
  parameters:
    value: int((bit_samples - n_keep) / 2)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: samp_rate_new
  id: variable
  parameters:
    value: samp_rate / decim
  states: {}
- name: selected_frequency
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '80000'
    step: '10000'
    stop: '3650000000'
    value: '1333313000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate_new // bitss
  states: {}
- name: sps_0
  id: variable
  parameters:
    value: samp_rate
  states: {state: disabled}
- name: analog_feedforward_agc_cc_0
  id: analog_feedforward_agc_cc
  parameters:
    num_samples: int(sps * bitss / 4)
    reference: '1.0'
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-50'
    type: complex
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-(n_keep / 2.0)'
    type: float
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/output.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/panagivths/Downloads/hello_world-capture.raw
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: sps
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: frame_start
    type: byte
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: cutoff_linear_vol
    init: '0'
    low: cutoff_linear_vol
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: (0, 1, 0, 1, 0, 0, 1, 1)
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '10101001'
    tagname: frame_start
    threshold: '1'
    type: byte
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '0.1'
    osps: bit_samples
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_EARLY_LATE
    type: ff
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: bit_samples
    taps: '[0]*n_skip + [1]*n_keep + [0]*(bit_samples - n_keep - n_skip)'
    type: fff
  states: {}
- name: iio_pluto_source_1
  id: iio_pluto_source
  parameters:
    bandwidth: '200000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: selected_frequency
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '2500'
    decim: decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '5000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Mag
    min: '0'
    type: float
    update_time: '0.05'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    rate: '50'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: TX Re
    label2: TX Im
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    label1: RX Threshold
    size: '256'
    srate: samp_rate_new
    type: float
    update_time: '0.25'
    ymax: '2'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {state: disabled}

connections:
- [analog_feedforward_agc_cc_0, '0', blocks_complex_to_mag_0, '0']
- [analog_feedforward_agc_cc_0, '0', qtgui_sink_x_0_0, '0']
- [analog_pwr_squelch_xx_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_const_vxx_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_complex_to_mag_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_number_sink_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_file_source_0, '0', analog_pwr_squelch_xx_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_xx_0, '0', virtual_sink_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_repeat_0, '0', blocks_multiply_xx_0, '0']
- [blocks_tagged_stream_align_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_threshold_ff_0, '0', fir_filter_xxx_1, '0']
- [blocks_throttle_0, '0', low_pass_filter_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', blocks_repeat_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_tagged_stream_align_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_threshold_ff_0, '0']
- [fir_filter_xxx_1, '0', blocks_add_const_vxx_0, '0']
- [iio_pluto_source_1, '0', low_pass_filter_0, '0']
- [iio_pluto_source_1, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_feedforward_agc_cc_0, '0']
- [virtual_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
