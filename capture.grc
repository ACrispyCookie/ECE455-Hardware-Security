options:
  parameters:
    author: tsiantosd
    generate_options: qt_gui
    id: capture
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: selected_frequency
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '80000'
    step: '10000'
    stop: '3650000000'
    value: '1333315000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/tsiantosd/Desktop/hello_world-capture-8-bits.raw
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/tsiantosd/Desktop/capture.raw
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: iio_pluto_source_1
  id: iio_pluto_source
  parameters:
    bandwidth: '200000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: selected_frequency
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_sink_x_0_0, '0']
- [iio_pluto_source_1, '0', blocks_file_sink_0, '0']
- [iio_pluto_source_1, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
